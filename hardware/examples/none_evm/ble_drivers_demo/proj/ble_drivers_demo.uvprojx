# Keil uVision project ble_drivers_demo.uvprojx, settings and files
target drivers_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_5_stack
  AfterMake: fromelf.exe  --text  -c -o host_app.txt  Objects/ble_5_stack.axf
  AfterMake: fromelf.exe  --bin -o host_app.bin  Objects/ble_5_stack.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_ADV_MEM_ALLOOC_NEW,CFG_SIMPLE_PRINTF
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_ota;..\code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0_host_app.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c demo_peripheral.c time_rtc.c
  group profiles
    ../../../../components/ble/profiles/ble_ota/: ota.c ota_service.c
  group driver
    ../../../../components/driver/: driver_iic.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_timer.c driver_ssp.c driver_keyscan.c driver_wdt.c driver_i2s.c driver_codec.c driver_efuse.c driver_rtc.c driver_uart.c driver_pwm.c driver_exti.c driver_pdm.c driver_adc.c
  group ble_lib_plf
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group ble_lib_patch
    ../../../../components/modules/patch/: patch.c
    ../../../../components/ble/library/: fr8010h_stack.lib
software components: CMSIS:CORE 5.5.0
